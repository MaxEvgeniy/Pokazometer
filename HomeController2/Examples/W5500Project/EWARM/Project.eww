<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\ProjectW5500.ewp</path>
  </project>
  <batchBuild />
</workspace>
